options:
  parameters:
    author: fabian
    generate_options: qt_gui
    id: recepcionPlaca
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.250'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_uchar_to_float_2
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport cv2\nimport csv\nimport time\nfrom pathlib import Path\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self, width=50, height=40, out_root=\"./dataset_rx_yolo\", show=True):\n        gr.sync_block.__init__(self,\n            name=\"bits2img_id_csv\",\n            in_sig=[np.uint8],\n            out_sig=None)\n\n        self.w = int(width)\n        self.h = int(height)\n        self.expected = self.w * self.h\n        self.header   = np.array([1, 0, 1, 0, 1, 0, 0, 0, 1, 1], dtype=np.uint8)\n        self.id_len   = 8\n        self.buffer   = np.empty(0, dtype=np.uint8)\n        self.show     = bool(show)\n\n        # Dataset en disco\n        self.root     = Path(out_root)\n        self.dir_img  = self.root / \"autos_bw\"\n        self.dir_bits = self.root / \"autos_bits\"\n        self.csv_path = self.root / \"dataset_rx.csv\"\n\n        for d in (self.dir_img, self.dir_bits):\n            d.mkdir(parents=True, exist_ok=True)\n        if not self.csv_path.exists():\n            with self.csv_path.open(\"w\", newline=\"\") as f:\n                csv.writer(f).writerow([\"num_auto\", \"bw_plate\", \"bits\"])\n\n        self.rep_count = {}\n\n    def _save_record(self, car_id, img_bw, bits):\n        rep_no = self.rep_count.get(car_id, 1)\n        self.rep_count[car_id] = rep_no + 1\n\n        stem = f\"auto{car_id:03d}_rep{rep_no:02d}\"\n        img_path  = self.dir_img  / f\"{stem}.png\"\n        bits_path = self.dir_bits / f\"{stem}.npy\"\n\n        cv2.imwrite(str(img_path), img_bw)\n        np.save(bits_path, bits.astype(np.uint8))\n\n        with self.csv_path.open(\"a\", newline=\"\") as f:\n            csv.writer(f).writerow([car_id, str(img_path), bits.tolist()])\n\n        print(f\"📁 Guardado {stem}\")\n\n    def work(self, input_items, output_items):\n        data = input_items[0]\n        if len(data) == 0:\n            return 0\n        self.buffer = np.append(self.buffer, data)\n\n        pkt_len = len(self.header) + self.id_len + self.expected\n        while True:\n            lim = len(self.buffer) - pkt_len\n            if lim < 0:\n                break\n\n            sync_found = False\n            for i in range(lim + 1):\n                posible_header = self.buffer[i:i+len(self.header)]\n\n                if np.array_equal(posible_header, self.header):\n                    invert = False\n                elif np.array_equal(1 - posible_header, self.header):\n                    invert = True\n                else:\n                    continue\n\n                start_id  = i + len(self.header)\n                start_img = start_id + self.id_len\n                end_img   = start_img + self.expected\n                if len(self.buffer) < end_img:\n                    break\n\n                id_bits    = self.buffer[start_id:start_id + self.id_len]\n                plate_bits = self.buffer[start_img:end_img]\n\n                if invert:\n                    id_bits = 1 - id_bits\n                    plate_bits = 1 - plate_bits\n\n                car_id = np.packbits(id_bits)[0]\n                self.buffer = self.buffer[end_img:]\n                sync_found = True\n\n                img_bw = (1 - plate_bits).astype(np.uint8).reshape(self.h, self.w) * 255\n\n                if self.show:\n                    disp = img_bw.copy()\n                    cv2.putText(disp, f\"Auto {car_id:03d}\", (2, 14),\n                                cv2.FONT_HERSHEY_SIMPLEX, 0.4, 255, 1, cv2.LINE_AA)\n                    cv2.imshow(\"Placa RX\", disp)\n                    cv2.waitKey(1)\n\n                self._save_record(car_id, img_bw, plate_bits)\n                break\n\n            if not sync_found:\n                if len(self.buffer) > 10 * pkt_len:\n                    self.buffer = self.buffer[-10*pkt_len:]\n                break\n\n        return len(data)\n\n"
    height: '40'
    out_root: '"./data"'
    show: 'True'
    width: '50'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 120e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '30'
    interp: '1'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*30
    samp_rate: samp_rate
    sym_rate: samp_rate/30
    type: fir_filter_fff
  states: {state: bypassed}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433e6
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_uchar_to_float_2, '0', rational_resampler_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_2, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', digital_costas_loop_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_uchar_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_add_const_vxx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
