options:
  parameters:
    author: fabian
    generate_options: qt_gui
    id: ModulacionPlaca
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 433e2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 433e6
    offset: '0'
    phase: '0'
    samp_rate: 1e9
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '59'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '15'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_2
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "############################################################\n#   csv_bits_src.py  –  con ID del auto in‑band + tag       #\n############################################################\nimport csv, ast, numpy as np, pmt\nfrom gnuradio import gr\n\nclass csv_bits_src(gr.basic_block):\n\n    def __init__(self,\n                 csv_path=\"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset_yolo/dataset_yolo.csv\",\n                 repeats=10):\n\n        # ---- parámetros generales ----\n        self.repeats = int(repeats)\n        self.header  = np.array([1,1,1,0,1,0,1,0,1], dtype=np.uint8)\n\n        # ---- cargar CSV -------------------------------------------------\n        self.bits_list = []   # [(id, bits), ...]\n        with open(csv_path, newline=\"\") as f:\n            rdr = csv.DictReader(f)\n            for row in rdr:\n                bits = np.array(ast.literal_eval(row[\"bits\"]), dtype=np.uint8)\n                if bits.size != 2000:\n                    print(f\"⚠️  fila {row['num_auto']} tamaño {bits.size}\")\n                    continue\n                car_id = int(row[\"num_auto\"])  # 1..182\n                if not (0 < car_id < 256):\n                    print(f\"⚠️  ID {car_id} fuera de rango 1‑255\")\n                    continue\n                self.bits_list.append((car_id, bits))\n\n        if not self.bits_list:\n            raise RuntimeError(\"CSV sin bit‑arrays válidos.\")\n\n        # ---- estado interno --------------------------------------------\n        self.row_idx     = 0\n        self.repeat_left = self.repeats\n        self._build_payload()\n\n        gr.basic_block.__init__(self, name=\"csv_bits_src\",\n                                in_sig=None, out_sig=[np.uint8])\n\n    # ------------------------------------------------------------------ #\n    def _build_payload(self):\n        car_id, bits = self.bits_list[self.row_idx]\n\n        # 1 byte con el ID (uint8)\n        id_byte   = np.array([car_id], dtype=np.uint8).view(np.uint8)\n        # convertir byte→bits (8 bits MSB primero)\n        id_bits   = np.unpackbits(id_byte)\n\n        self.payload    = np.concatenate((self.header, id_bits, bits))\n        self.packet_len = len(self.payload)\n        self.cur_id     = car_id  # guarda para etiquetar\n\n    def _next_row(self):\n        self.row_idx += 1\n        if self.row_idx >= len(self.bits_list):\n            return False\n        self.repeat_left = self.repeats\n        self._build_payload()\n        return True\n\n    # ------------------------------------------------------------------ #\n    def general_work(self, in_items, out_items):\n        out = out_items[0]\n        if len(out) < self.packet_len:\n            return 0\n\n        out[:self.packet_len] = self.payload\n\n        # tag con longitud y con ID (opcional pero útil)\n        offset = self.nitems_written(0)\n        self.add_item_tag(0, offset,\n                          pmt.intern(\"packet_len\"),\n                          pmt.from_long(self.packet_len))\n        self.add_item_tag(0, offset,\n                          pmt.intern(\"car_id\"),\n                          pmt.from_long(self.cur_id))\n\n        # mensaje de progreso\n        rep_idx = self.repeats - self.repeat_left + 1\n        print(f\"Auto {self.cur_id:03d}  réplica {rep_idx}\")\n\n        # administración de repeticiones\n        self.repeat_left -= 1\n        if self.repeat_left == 0:\n            if not self._next_row():\n                return -1\n        return self.packet_len\n\n"
    csv_path: '"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset_yolo/dataset_yolo.csv"'
    repeats: '2'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "#############################################################\n# bits2img_id_csv – RX con dataset y CSV                    #\n#############################################################\n\nimport cv2, csv, numpy as np\nfrom pathlib import Path\nfrom gnuradio import gr\n\nclass bits2img_id_csv(gr.basic_block):\n    def __init__(self,\n                 width=50,\n                 height=40,\n                 out_root=\"./dataset_rx_yolo\",\n                 show=True):\n\n        super().__init__(name=\"bits2img_id_csv\",\n                         in_sig=[np.uint8],\n                         out_sig=None)\n\n        # --- imagen / cabecera ---\n        self.w = int(width)\n        self.h = int(height)\n        self.expected = self.w * self.h\n        self.header   = np.array([1,1,1,0,1,0,1,0,1], dtype=np.uint8)\n        self.id_len   = 8\n        self.buffer   = np.empty(0, dtype=np.uint8)\n        self.show     = bool(show)\n\n        # --- dataset en disco -----\n        self.root     = Path(out_root)\n        self.dir_img  = self.root / \"autos_bw\"\n        self.dir_bits = self.root / \"autos_bits\"\n        self.csv_path = self.root / \"dataset_rx.csv\"\n\n        for d in (self.dir_img, self.dir_bits):\n            d.mkdir(parents=True, exist_ok=True)\n        if not self.csv_path.exists():\n            with self.csv_path.open(\"w\", newline=\"\") as f:\n                csv.writer(f).writerow([\"num_auto\", \"bw_plate\", \"bits\"])\n\n        # --- contadores de réplica por auto ---\n        self.rep_count = {}   # {id: next_rep_no}\n\n    # ----------------------------------------------------------- #\n    def _save_record(self, car_id: int, img_bw: np.ndarray, bits: np.ndarray):\n        # siguiente réplica #\n        rep_no = self.rep_count.get(car_id, 1)\n        self.rep_count[car_id] = rep_no + 1\n\n        stem = f\"auto{car_id:03d}_rep{rep_no:02d}\"\n        img_path  = self.dir_img  / f\"{stem}.png\"\n        bits_path = self.dir_bits / f\"{stem}.npy\"\n\n        cv2.imwrite(str(img_path), img_bw)\n        np.save(bits_path, bits.astype(np.uint8))\n\n        # guardar CSV\n        with self.csv_path.open(\"a\", newline=\"\") as f:\n            csv.writer(f).writerow([car_id, str(img_path), bits.tolist()])\n\n        print(f\"📁 Guardado {stem}\")\n\n    # ----------------------------------------------------------- #\n    def general_work(self, in_items, out_items):\n        data = in_items[0]\n        if len(data) == 0:\n            return 0\n        self.buffer = np.append(self.buffer, data)\n\n        pkt_len = len(self.header) + self.id_len + self.expected\n        while True:\n            lim = len(self.buffer) - pkt_len\n            if lim < 0:\n                break\n\n            sync_found = False\n            for i in range(lim + 1):\n                if np.array_equal(self.buffer[i:i+len(self.header)], self.header):\n                    # zonas\n                    start_id  = i + len(self.header)\n                    start_img = start_id + self.id_len\n                    end_img   = start_img + self.expected\n                    if len(self.buffer) < end_img:\n                        break  # espera más bits\n                    # --- ID ---\n                    id_bits = self.buffer[start_id:start_id+self.id_len]\n                    car_id  = np.packbits(id_bits)[0]\n                    # --- placa bits ---\n                    plate_bits = self.buffer[start_img:end_img]\n                    self.buffer = self.buffer[end_img:]  # descartar procesado\n                    sync_found = True\n\n                    # reconstruir imagen (1=blanco)\n                    img_bw = (1 - plate_bits).astype(np.uint8).reshape(self.h, self.w) * 255\n\n                    if self.show:\n                        disp = img_bw.copy()\n                        cv2.putText(disp, f\"Auto {car_id:03d}\", (2, 14),\n                                    cv2.FONT_HERSHEY_SIMPLEX, 0.4, 255, 1, cv2.LINE_AA)\n                        cv2.imshow(\"Placa RX\", disp)\n                        cv2.waitKey(1)\n\n                    # --- guardar en dataset / CSV\n                    self._save_record(car_id, img_bw, plate_bits)\n\n                    break\n            if not sync_found:\n                # limitar tamaño de buffer\n                if len(self.buffer) > 10 * pkt_len:\n                    self.buffer = self.buffer[-10*pkt_len:]\n                break\n\n        self.consume(0, len(data))\n        return 0\n\n"
    height: '40'
    out_root: '"./dataset_rx_yolo"'
    show: 'True'
    width: '50'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Error"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_5
  id: qtgui_time_sink_x
  parameters:
    name: '"FINAL"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '15'
    interp: '1'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: placa
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: throttle
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: placa
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: throttle
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0, '0', blocks_xor_xx_1, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_throttle2_0, '0', blocks_xor_xx_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_1_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_2, '0', qtgui_time_sink_x_5, '0']
- [blocks_uchar_to_float_2, '0', rational_resampler_xxx_0, '0']
- [blocks_xor_xx_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_xor_xx_1, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_2, '0']
- [digital_binary_slicer_fb_0, '0', blocks_xor_xx_1, '1']
- [epy_block_0_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_uchar_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
