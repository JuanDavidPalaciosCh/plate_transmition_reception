options:
  parameters:
    author: fabian
    generate_options: qt_gui
    id: ModulacionPlaca
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 433e2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 433e6
    offset: '0'
    phase: '0'
    samp_rate: 1e9
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '59'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '15'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_2
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import os, csv, cv2, numpy as np\nfrom pathlib import Path\nfrom gnuradio import gr\n\nclass bits2dataset(gr.basic_block):\n    \"\"\"\n    Reconstruye placas 45×30 desde un flujo de bits, las muestra y crea\n    un dataset en disco + CSV donde se guarda *cada réplica*.\n\n    CSV final:\n        imagen,bits\n        dataset_rx/autos/auto001_rep01.png,dataset_rx/autos_bits/auto001_rep01.npy\n        dataset_rx/autos/auto001_rep02.png,dataset_rx/autos_bits/auto001_rep02.npy\n        ...\n\n    Parámetros\n    ----------\n    out_root : str   Carpeta destino del dataset.\n    n_images : int  Cantidad de autos distintos (182).\n    repeats  : int  Réplicas por auto (10).\n    width,height :  dimensiones (45×30).\n    show : bool     Mostrar ventana OpenCV.\n    \"\"\"\n\n    def __init__(self,\n                 out_root=\"./dataset_rx\",\n                 n_images=182,\n                 repeats=10,\n                 width=45,\n                 height=30,\n                 show=True):\n\n        super().__init__(name=\"bits2dataset\", in_sig=[np.uint8], out_sig=None)\n\n        # ---- ajustes básicos ----\n        self.width  = int(width)\n        self.height = int(height)\n        self.show   = bool(show)\n\n        # ---- cabecera + longitudes ----\n        self.expected = self.width * self.height\n        self.header   = np.array([1,1,1,0,1,0,1,0,1], dtype=np.uint8)\n        self.buffer   = np.empty(0, dtype=np.uint8)\n\n        # ---- control de secuencia ----\n        self.n_images     = int(n_images)\n        self.repeats      = int(repeats)\n        self.cur_img_idx  = 1         # auto actual (1..n_images)\n        self.repeat_left  = self.repeats\n        self.rep_no       = 1         # réplica actual (1..repeats)\n\n        # ---- rutas ----\n        self.root      = Path(out_root)\n        self.dir_img   = self.root / \"autos\"\n        self.dir_bits  = self.root / \"autos_bits\"\n        self.csv_path  = self.root / \"dataset_rx_index.csv\"\n\n        for d in (self.dir_img, self.dir_bits):\n            d.mkdir(parents=True, exist_ok=True)\n        if not self.csv_path.exists():\n            with self.csv_path.open(\"w\", newline=\"\") as f:\n                csv.writer(f).writerow([\"imagen\", \"bits\"])\n\n    # ----------------------------------------------------------------- #\n    def general_work(self, in_items, out_items):\n        data = in_items[0]\n        if len(data) == 0:\n            return 0\n        self.buffer = np.append(self.buffer, data)\n\n        while True:\n            limit = len(self.buffer) - len(self.header) - self.expected\n            if limit < 0:\n                break\n\n            found = False\n            for i in range(limit + 1):\n                if np.array_equal(self.buffer[i:i+len(self.header)], self.header):\n                    start = i + len(self.header); end = start + self.expected\n                    if len(self.buffer) >= end:\n                        frame = self.buffer[start:end]\n                        self.buffer = self.buffer[end:]\n                        self._save_frame(frame)        # ⬅️ guardar réplica\n                        found = True\n                        break\n                    else:\n                        break\n            if not found:\n                if len(self.buffer) > 10*(self.expected+len(self.header)):\n                    self.buffer = self.buffer[-(self.expected+len(self.header)):]\n                break\n\n        self.consume(0, len(data))\n        return 0\n\n    # ----------------------------------------------------------------- #\n    def _save_frame(self, bits):\n        img = (1 - bits).astype(np.uint8).reshape(self.height, self.width)*255\n\n        if self.show:\n            cv2.imshow(\"RX placa\", img)\n            cv2.waitKey(1)\n\n        # nombres con autoXXX_repYY\n        stem = f\"auto{self.cur_img_idx:03d}_rep{self.rep_no:02d}\"\n        img_path  = self.dir_img  / f\"{stem}.png\"\n        bits_path = self.dir_bits / f\"{stem}.npy\"\n\n        cv2.imwrite(str(img_path), img)\n        np.save(bits_path, bits.astype(np.uint8))\n\n        with self.csv_path.open(\"a\", newline=\"\") as f:\n            csv.writer(f).writerow([str(img_path), str(bits_path)])\n\n        print(f\"📁 Guardado {stem}\")\n\n        # ---- actualizar contadores ----\n        self.repeat_left -= 1\n        self.rep_no      += 1\n        if self.repeat_left == 0:\n            self.cur_img_idx += 1\n            self.repeat_left  = self.repeats\n            self.rep_no       = 1\n            if self.cur_img_idx > self.n_images:\n                print(\"✅  Dataset completo.\")\n\n"
    height: '40'
    n_images: '182'
    out_root: '"./dataset_rx"'
    repeats: '10'
    show: 'False'
    width: '50'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import os, glob, cv2, numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass img2bits(gr.basic_block):\n    \"\"\"\n    Transmite N imágenes secuencialmente; cada una se repite `repeats` veces.\n\n    Parameters\n    ----------\n    dir_path : str\n        Carpeta que contiene las imágenes auto*.jpeg.\n    repeats : int\n        Número de veces que se enviará cada imagen.\n    mode : {\"bits\", \"int\"}\n        Igual que en tu versión original.\n    \"\"\"\n\n    def __init__(self,\n                 dir_path=\"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset/autos/\",\n                 repeats=10,\n                 mode=\"bits\"):\n        self.mode    = mode.lower().strip()\n        self.repeats = int(repeats)\n\n        # ── Obtener lista de archivos ───────────────────────────────────────\n        pattern = os.path.join(dir_path, \"auto*.jp*g\")  # acepta .jpeg o .jpg\n        self.files = sorted(glob.glob(pattern))\n        if not self.files:\n            raise RuntimeError(f\"No se encontraron imágenes con patrón {pattern}\")\n\n        # ── Señales de E/S ──────────────────────────────────────────────────\n        out_sig = [np.uint8] if self.mode == \"bits\" else None\n        gr.basic_block.__init__(self, name=\"img2bits_seq\",\n                                in_sig=None, out_sig=out_sig)\n\n        # ── Cabecera fija ───────────────────────────────────────────────────\n        self.header = np.array([1,1,1,0,1,0,1,0,1], dtype=np.uint8)\n\n        # ── Estado interno ──────────────────────────────────────────────────\n        self.file_idx   = 0          # índice en self.files\n        self.repeat_left = self.repeats\n        self._load_payload()         # crea self.payload y self.packet_len\n\n        if self.mode == \"int\":\n            self.message_port_register_out(pmt.intern(\"out\"))\n\n    # ------------------------------------------------------------------- #\n    #  UTILIDADES                                                         #\n    # ------------------------------------------------------------------- #\n    def _extract_bits(self, path):\n        \"\"\"\n        Recorta la placa, binariza y devuelve un vector 0/1 de longitud fija.\n        (Mismo método que tenías, sin cambios funcionales).\n        \"\"\"\n        img = cv2.imread(path)\n        if img is None:\n            raise RuntimeError(f\"Imagen no encontrada: {path}\")\n\n        hsv  = cv2.cvtColor(img, cv2.COLOR_BGR2HSV)\n        mask = cv2.inRange(hsv, (20,100,100), (35,255,255))\n        mask = cv2.morphologyEx(mask, cv2.MORPH_CLOSE,\n                                cv2.getStructuringElement(cv2.MORPH_RECT, (5,5)))\n\n        cnts, _ = cv2.findContours(mask, cv2.RETR_EXTERNAL, cv2.CHAIN_APPROX_SIMPLE)\n        plate, possible, area_max = None, None, 0\n        for c in cnts:\n            x,y,w,h = cv2.boundingRect(c)\n            r, area = w/float(h), w*h\n            if 1.8 < r < 3.2 and w > 40:\n                plate = img[y:y+h, x:x+w]; break\n            elif area > area_max and w > 60:\n                possible, area_max = img[y:y+h, x:x+w], area\n        if plate is None and possible is not None:\n            plate = possible\n            print(f\"⚠️  {os.path.basename(path)}: placa fuera de proporción ideal\")\n\n        if plate is None:\n            print(f\"No se detectó placa en {path}, rellenando...\")\n            return np.zeros(50 * 40, dtype=np.uint8)\n\n        plate = cv2.resize(plate, (50, 40))\n        gray  = cv2.cvtColor(plate, cv2.COLOR_BGR2GRAY)\n        _, bn = cv2.threshold(gray, 100, 255, cv2.THRESH_BINARY_INV)\n        return (bn == 0).flatten().astype(np.uint8)\n\n    def _load_payload(self):\n        \"\"\"Carga bits de la imagen actual y prepara self.payload / len.\"\"\"\n        actual_path   = self.files[self.file_idx]\n        img_bits      = self._extract_bits(actual_path)\n        self.payload  = np.concatenate((self.header, img_bits))\n        self.packet_len = len(self.payload)\n\n    def _advance_image(self):\n        \"\"\"Pasa a la siguiente imagen y resetea el contador de repeticiones.\"\"\"\n        self.file_idx += 1\n        if self.file_idx >= len(self.files):\n            self.file_idx = len(self.files)  # deja apuntando al final\n            return False                     # ya no hay más imágenes\n        self.repeat_left = self.repeats\n        self._load_payload()\n        return True\n\n    # ------------------------------------------------------------------- #\n    #  GNU RADIO                                                          #\n    # ------------------------------------------------------------------- #\n    def general_work(self, in_items, out_items):\n        if self.mode != \"bits\":\n            return 0\n\n        out = out_items[0]\n        if len(out) < self.packet_len:\n            return 0  # el búfer aún no alcanza\n\n        # ── Copiar paquete y etiquetar ───────────────────────────────────\n        out[:self.packet_len] = self.payload\n        self.add_item_tag(0, self.nitems_written(0),\n                          pmt.intern(\"packet_len\"),\n                          pmt.from_long(self.packet_len))\n\n        # ── ⬇️  mensaje de progreso  ⬇️ ───────────────────────────\n        rep_no = self.repeats - self.repeat_left + 1          # 1..10\n        img_no = self.file_idx + 1                            # 1..182\n        print(f\"Imagen {img_no:03d} mandada {rep_no}\")\n        # ────────────────────────────────────────────────────────────────\n\n        # ── Gestionar recuento y paso a la siguiente ────────────────────\n        self.repeat_left -= 1\n        if self.repeat_left == 0:\n            if not self._advance_image():     # sin más imágenes\n                return -1                     # EOF → detener flujo\n\n        return self.packet_len\n\n    def start(self):\n        \"\"\"En modo 'int' publica cada paquete en un puerto de mensajes.\"\"\"\n        if self.mode == \"int\":\n            packed = np.packbits(self.payload)\n            value  = int.from_bytes(packed.tobytes(), \"big\")\n            msg = pmt.cons(pmt.PMT_NIL,\n                           pmt.from_uint64(value)\n                           if value.bit_length() <= 64\n                           else pmt.init_u8vector(len(packed), packed))\n            self.message_port_pub(pmt.intern(\"out\"), msg)\n        return super().start()\n\n"
    dir_path: '"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset/autos/"'
    mode: '"bits"'
    repeats: '10'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "#############################################################\n#  bits2img – reconstruye imagen 45×30 desde un paquete     #\n#  de bits (uchar 0/1) y la muestra con OpenCV              #\n#############################################################\n\nimport cv2\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    def __init__(self, width=45, height=30, show=True):\n        gr.basic_block.__init__(self,\n            name=\"bits2img\",\n            in_sig=[np.uint8],\n            out_sig=None,\n        )\n        self.width = int(width)\n        self.height = int(height)\n        self.show = bool(show)\n\n        self.expected = self.width * self.height\n        self.header = np.array([1, 1, 1, 0, 1, 0, 1, 0, 1], dtype=np.uint8)\n        self.buffer = np.empty(0, dtype=np.uint8)\n\n    def general_work(self, in_items, out_items):\n        inp = in_items[0]\n        nread = len(inp)\n\n        if nread == 0:\n            return 0\n\n        self.buffer = np.append(self.buffer, inp)\n\n        while True:\n            search_limit = len(self.buffer) - len(self.header) - self.expected\n            if search_limit < 0:\n                break\n\n            found = False\n            for i in range(search_limit + 1):\n                if np.array_equal(self.buffer[i:i + len(self.header)], self.header):\n                    start = i + len(self.header)\n                    end = start + self.expected\n                    if len(self.buffer) >= end:\n                        frame_bits = self.buffer[start:end]\n                        self.buffer = self.buffer[end:]  # quitar todo hasta fin del paquete\n                        img = (1 - frame_bits).astype(np.uint8) * 255\n                        img = img.reshape(self.height, self.width)\n                        if self.show:\n                            cv2.imshow(\"Imagen reconstruida\", img)\n                            cv2.waitKey(1)\n                        found = True\n                        break\n                    else:\n                        break  # esperar más datos\n\n            if not found:\n                # No encontramos header válido: eliminar parte frontal para evitar overflow\n                if len(self.buffer) > 10 * (self.expected + len(self.header)):\n                    self.buffer = self.buffer[-(self.expected + len(self.header)):]\n                break\n\n        self.consume(0, nread)\n        return 0\n\n"
    height: '40'
    show: 'True'
    width: '50'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Error"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_5
  id: qtgui_time_sink_x
  parameters:
    name: '"FINAL"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '15'
    interp: '1'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: placa
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: throttle
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: placa
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: throttle
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0, '0', blocks_xor_xx_1, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_throttle2_0, '0', blocks_xor_xx_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_1_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_2, '0', qtgui_time_sink_x_5, '0']
- [blocks_uchar_to_float_2, '0', rational_resampler_xxx_0, '0']
- [blocks_xor_xx_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_xor_xx_1, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_2, '0']
- [digital_binary_slicer_fb_0, '0', blocks_xor_xx_1, '1']
- [epy_block_0_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_uchar_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
