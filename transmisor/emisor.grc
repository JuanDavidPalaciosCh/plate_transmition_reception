options:
  parameters:
    author: Juan David Palacios ch
    generate_options: qt_gui
    id: ModulacionPlaca
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '30'
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "############################################################\n#   rand_img_src.py – envía 1 imagen aleatoria por disparo #\n############################################################\nimport csv, ast, time, random, numpy as np, pmt\nfrom gnuradio import gr\n\n\nclass rand_img_src(gr.basic_block):\n    \"\"\"\n    Puerto de entrada  : mensaje (trigger)  -> self.port_id(\"trigger\")\n    Puerto de salida   : stream  uint8\n    Acción             : cada mensaje ≫ envía 1 paquete bits  +  ceros el resto\n    \"\"\"\n\n    def __init__(\n        self,\n        csv_path=\"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset_yolo/dataset_yolo.csv\",\n        header_bits=[1, 0, 1, 0, 1, 0, 0, 0, 1, 1],\n        max_pkt_rate=10,   # ≈ muestras/s de los paquetes (para relleno)\n    ):\n        gr.basic_block.__init__(\n            self, name=\"rand_img_src\", in_sig=None, out_sig=[np.uint8]\n        )\n\n        # ── carga CSV ────────────────────────────────────────────────\n        self.bits_list = []\n        with open(csv_path, newline=\"\") as f:\n            for row in csv.DictReader(f):\n                bits = np.array(ast.literal_eval(row[\"bits\"]), dtype=np.uint8)\n                if bits.size == 2000:\n                    self.bits_list.append((int(row[\"num_auto\"]), bits))\n        if not self.bits_list:\n            raise RuntimeError(\"CSV vacío o corrupto\")\n\n        self.header   = np.array(header_bits, dtype=np.uint8)\n        self.zero_buf = np.zeros(max_pkt_rate, dtype=np.uint8)\n\n        # estado\n        self.tx_queue = np.empty(0, dtype=np.uint8)   # bytes pendientes\n\n        # ── puerto de disparo ────────────────────────────────────────\n        self.message_port_register_in(pmt.intern(\"trigger\"))\n        self.set_msg_handler(pmt.intern(\"trigger\"), self._on_trigger)\n\n    # .................................................................\n    def _on_trigger(self, _msg):\n        \"\"\"Elige imagen aleatoria y la pone en cola para transmitir una vez.\"\"\"\n        car_id, bits = random.choice(self.bits_list)\n        id_bits = np.unpackbits(np.array([car_id], dtype=np.uint8))\n        pkt = np.concatenate((self.header, id_bits, bits))\n        self.tx_queue = np.concatenate((self.tx_queue, pkt))\n\n    # .................................................................\n    def general_work(self, in_items, out_items):\n        out = out_items[0]\n        n   = len(out)\n\n        # ¿hay paquete pendiente?\n        if self.tx_queue.size:\n            n_copy = min(n, self.tx_queue.size)\n            out[:n_copy] = self.tx_queue[:n_copy]\n            self.tx_queue = self.tx_queue[n_copy:]\n            return n_copy\n\n        # si no, rellenamos con ceros para evitar underflow\n        n_zero = min(n, self.zero_buf.size)\n        out[:n_zero] = self.zero_buf[:n_zero]\n        return n_zero\n\n"
    csv_path: '"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset_yolo/dataset_yolo.csv"'
    header_bits: '[1, 0, 1, 0, 1, 0, 0, 0, 1, 1]'
    max_pkt_rate: '10'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "############################################################\n#   csv_bits_src.py  –  con relleno de ceros en la pausa    #\n############################################################\nimport csv, ast, time, numpy as np, pmt\nfrom gnuradio import gr\n\n\nclass csv_bits_src(gr.basic_block):\n    def __init__(\n        self,\n        csv_path=(\n            \"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/\"\n            \"Proyecto final/dataset_yolo/dataset_yolo.csv\"\n        ),\n        repeats=10,\n        pause_s=0.5,\n    ):\n        # ─── parámetros generales ───────────────────────────────────\n        self.repeats  = int(repeats)\n        self.pause_s  = pause_s\n        self.header   = np.array([1, 0, 1, 0, 1, 0, 0, 0, 1, 1], dtype=np.uint8)\n\n        # ─── cargar CSV ─────────────────────────────────────────────\n        self.bits_list = []\n        with open(csv_path, newline=\"\") as f:\n            for row in csv.DictReader(f):\n                bits = np.array(ast.literal_eval(row[\"bits\"]), dtype=np.uint8)\n                if bits.size != 2000:\n                    print(f\"⚠️  fila {row['num_auto']} tamaño {bits.size}\")\n                    continue\n                car_id = int(row[\"num_auto\"])\n                if not (0 < car_id < 256):\n                    print(f\"⚠️  ID {car_id} fuera de rango 1‑255\")\n                    continue\n                self.bits_list.append((car_id, bits))\n\n        if not self.bits_list:\n            raise RuntimeError(\"CSV sin bit‑arrays válidos.\")\n\n        # ─── estado interno ─────────────────────────────────────────\n        self.row_idx       = 0\n        self.repeat_left   = self.repeats\n        self._build_payload()\n\n        # primer envío inmediato\n        self.next_emit_t   = 0.0\n\n        gr.basic_block.__init__(\n            self, name=\"csv_bits_src\", in_sig=None, out_sig=[np.uint8]\n        )\n\n    # ------------------------------------------------------------------\n    def _build_payload(self):\n        car_id, bits = self.bits_list[self.row_idx]\n        id_bits      = np.unpackbits(np.array([car_id], dtype=np.uint8))\n        self.payload     = np.concatenate((self.header, id_bits, bits))\n        self.packet_len  = len(self.payload)\n        self.cur_id      = car_id\n\n    def _next_row(self):\n        self.row_idx += 1\n        if self.row_idx >= len(self.bits_list):\n            return False\n        self.repeat_left = self.repeats\n        self._build_payload()\n        return True\n\n    # ------------------------------------------------------------------\n    def general_work(self, in_items, out_items):\n        out = out_items[0]\n        now = time.time()\n\n        # ≡≡ PAUSA: enviar ceros para evitar underflow ≡≡\n        if now < self.next_emit_t:\n            n = len(out)\n            if n:                       # sólo si hay espacio en el búfer\n                out[:n] = 0             # ceros lógicos\n            return n                    # informar que llenamos n muestras\n\n        # ≡≡ Enviar el paquete ≡≡\n        if len(out) < self.packet_len:\n            return 0                    # espera a tener búfer suficiente\n\n        out[: self.packet_len] = self.payload\n\n        # etiquetas\n        offset = self.nitems_written(0)\n        self.add_item_tag(0, offset, pmt.intern(\"packet_len\"),\n                          pmt.from_long(self.packet_len))\n        self.add_item_tag(0, offset, pmt.intern(\"car_id\"),\n                          pmt.from_long(self.cur_id))\n\n        # log\n        rep_idx = self.repeats - self.repeat_left + 1\n        print(f\"Auto {self.cur_id:03d}  réplica {rep_idx}\")\n\n        # programa la próxima pausa\n        self.next_emit_t = now + self.pause_s\n\n        # administra repeticiones\n        self.repeat_left -= 1\n        if self.repeat_left == 0:\n            if not self._next_row():\n                return -1               # fin de archivo\n\n        return self.packet_len\n\n"
    csv_path: '"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset_yolo/dataset_yolo.csv"'
    pause_s: '0.0005'
    repeats: '20'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: trigger
  id: variable_qtgui_msg_push_button
  parameters:
    label: msg
    msgName: trigger
    type: bool
    value: '1'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 433e6
    gain0: '80'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_repeat_0, '0', blocks_xor_xx_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_1_0, '0', blocks_add_xx_0, '0']
- [blocks_xor_xx_0, '0', blocks_uchar_to_float_1, '0']
- [epy_block_0, '0', blocks_repeat_0, '0']
- [epy_block_0_0, '0', blocks_repeat_0, '0']
- [trigger, pressed, epy_block_0, trigger]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
