options:
  parameters:
    author: fabian
    generate_options: qt_gui
    id: ModulacionPlaca
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '15'
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import os, glob, cv2, numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass img2bits(gr.basic_block):\n    \"\"\"\n    Transmite N imágenes secuencialmente; cada una se repite `repeats` veces.\n\n    Parameters\n    ----------\n    dir_path : str\n        Carpeta que contiene las imágenes auto*.jpeg.\n    repeats : int\n        Número de veces que se enviará cada imagen.\n    mode : {\"bits\", \"int\"}\n        Igual que en tu versión original.\n    \"\"\"\n\n    def __init__(self,\n                 dir_path=\"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset/autos/\",\n                 repeats=10,\n                 mode=\"bits\"):\n        self.mode    = mode.lower().strip()\n        self.repeats = int(repeats)\n\n        # ── Obtener lista de archivos ───────────────────────────────────────\n        pattern = os.path.join(dir_path, \"auto*.jp*g\")  # acepta .jpeg o .jpg\n        self.files = sorted(glob.glob(pattern))\n        if not self.files:\n            raise RuntimeError(f\"No se encontraron imágenes con patrón {pattern}\")\n\n        # ── Señales de E/S ──────────────────────────────────────────────────\n        out_sig = [np.uint8] if self.mode == \"bits\" else None\n        gr.basic_block.__init__(self, name=\"img2bits_seq\",\n                                in_sig=None, out_sig=out_sig)\n\n        # ── Cabecera fija ───────────────────────────────────────────────────\n        self.header = np.array([1,1,1,0,1,0,1,0,1], dtype=np.uint8)\n\n        # ── Estado interno ──────────────────────────────────────────────────\n        self.file_idx   = 0          # índice en self.files\n        self.repeat_left = self.repeats\n        self._load_payload()         # crea self.payload y self.packet_len\n\n        if self.mode == \"int\":\n            self.message_port_register_out(pmt.intern(\"out\"))\n\n    # ------------------------------------------------------------------- #\n    #  UTILIDADES                                                         #\n    # ------------------------------------------------------------------- #\n    def _extract_bits(self, path):\n        \"\"\"\n        Recorta la placa, binariza y devuelve un vector 0/1 de longitud fija.\n        (Mismo método que tenías, sin cambios funcionales).\n        \"\"\"\n        img = cv2.imread(path)\n        if img is None:\n            raise RuntimeError(f\"Imagen no encontrada: {path}\")\n\n        hsv  = cv2.cvtColor(img, cv2.COLOR_BGR2HSV)\n        mask = cv2.inRange(hsv, (20,100,100), (35,255,255))\n        mask = cv2.morphologyEx(mask, cv2.MORPH_CLOSE,\n                                cv2.getStructuringElement(cv2.MORPH_RECT, (5,5)))\n\n        cnts, _ = cv2.findContours(mask, cv2.RETR_EXTERNAL, cv2.CHAIN_APPROX_SIMPLE)\n        plate, possible, area_max = None, None, 0\n        for c in cnts:\n            x,y,w,h = cv2.boundingRect(c)\n            r, area = w/float(h), w*h\n            if 1.8 < r < 3.2 and w > 40:\n                plate = img[y:y+h, x:x+w]; break\n            elif area > area_max and w > 60:\n                possible, area_max = img[y:y+h, x:x+w], area\n        if plate is None and possible is not None:\n            plate = possible\n            print(f\"⚠️  {os.path.basename(path)}: placa fuera de proporción ideal\")\n\n        if plate is None:\n            raise RuntimeError(f\"No se detectó placa en {path}\")\n\n        plate = cv2.resize(plate, (50, 40))\n        gray  = cv2.cvtColor(plate, cv2.COLOR_BGR2GRAY)\n        _, bn = cv2.threshold(gray, 100, 255, cv2.THRESH_BINARY_INV)\n        return (bn == 0).flatten().astype(np.uint8)\n\n    def _load_payload(self):\n        \"\"\"Carga bits de la imagen actual y prepara self.payload / len.\"\"\"\n        actual_path   = self.files[self.file_idx]\n        img_bits      = self._extract_bits(actual_path)\n        self.payload  = np.concatenate((self.header, img_bits))\n        self.packet_len = len(self.payload)\n\n    def _advance_image(self):\n        \"\"\"Pasa a la siguiente imagen y resetea el contador de repeticiones.\"\"\"\n        self.file_idx += 1\n        if self.file_idx >= len(self.files):\n            self.file_idx = len(self.files)  # deja apuntando al final\n            return False                     # ya no hay más imágenes\n        self.repeat_left = self.repeats\n        self._load_payload()\n        return True\n\n    # ------------------------------------------------------------------- #\n    #  GNU RADIO                                                          #\n    # ------------------------------------------------------------------- #\n    def general_work(self, in_items, out_items):\n        if self.mode != \"bits\":\n            return 0\n\n        out = out_items[0]\n        if len(out) < self.packet_len:\n            return 0  # búfer aún pequeño\n\n        # Copiar payload y etiquetar\n        out[:self.packet_len] = self.payload\n        self.add_item_tag(0, self.nitems_written(0),\n                          pmt.intern(\"packet_len\"),\n                          pmt.from_long(self.packet_len))\n\n        # Gestionar recuento / avance\n        self.repeat_left -= 1\n        if self.repeat_left == 0:\n            if not self._advance_image():   # sin más imágenes → detener\n                return -1                   # señal EOF a GNU Radio\n\n        return self.packet_len\n\n    def start(self):\n        \"\"\"En modo 'int' publica cada paquete en un puerto de mensajes.\"\"\"\n        if self.mode == \"int\":\n            packed = np.packbits(self.payload)\n            value  = int.from_bytes(packed.tobytes(), \"big\")\n            msg = pmt.cons(pmt.PMT_NIL,\n                           pmt.from_uint64(value)\n                           if value.bit_length() <= 64\n                           else pmt.init_u8vector(len(packed), packed))\n            self.message_port_pub(pmt.intern(\"out\"), msg)\n        return super().start()\n\n"
    dir_path: '"/home/jpalaciosch/Documents/UNAL/Septimo semestre/Comunicaciones/Proyecto final/dataset/autos/"'
    mode: '"bits"'
    repeats: '10'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 433e6
    gain0: '30'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_repeat_0, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_repeat_0, '0', blocks_xor_xx_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_1_0, '0', blocks_add_xx_0, '0']
- [blocks_xor_xx_0, '0', blocks_uchar_to_float_1, '0']
- [epy_block_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
